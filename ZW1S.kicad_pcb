# Repository BIT-SGC/ZW1S-hardware

File Readme.md:

# ZW1S 7inch/5inch Quadcopter Upper Board

> silence is gold

## KiCad design ZW1S.kicad_pcb

Parts:
H1, H2, H3, H4, H6, H7, H8, H9, H11, H12, H13, H14, H16, H17, H18, H19: MountingHole_M2.5; MountingHole_2.5mm_Pad_Via
H5, H10, H15, H20: MountingHole_M3; MountingHole_3.2mm_M3_Pad_Via

Notes on the sheet:
机臂安装孔-3
机臂安装孔-4
机臂安装孔-2
机臂安装孔-1
SBC安装孔

Parts:
C11, C17, C19, C21: 4.7uF/10V; C_0603_1608Metric
C12: 10uF/50V; C_1206_3216Metric
C13, C18: 22uF/10V; C_1206_3216Metric
C14, C20, C22, C26: 100uF/35V; CP_Elec_6.3x7.7
C15: 3.3nF; C_0402_1005Metric
C16, C23, C24: 0.1uF; C_0402_1005Metric
C25, C28, C29, C30, C31: 4.7uF/50V; C_0805_2012Metric
C27: 75pF; C_0402_1005Metric
L1: 10uH; L_APV_APH0530
L2: 6.8uH; L_APV_APH0630
R7: 33.2K; R_0603_1608Metric
R8: 200K; R_0402_1005Metric
R9: 13.3K; R_0603_1608Metric
R10: 100K; R_0402_1005Metric
R11: 49.9R; R_0603_1608Metric
R12: 53.6K; R_0603_1608Metric
R13: 10.2K; R_0603_1608Metric
U4: TPS54302; SOT-23-6
U5: SCT2450; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm

Connections:
5V0_{assist}: C13.1, C18.1, C22.1, C26.1, L1.2, R11.1; also elsewhere on the board
5V0_{device}: C11.1, C14.1, C17.1, C19.1, C20.1, C21.1, L2.2, R12.2; also elsewhere on the board
GND: C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C25.2, C26.2, C28.2, C29.2, C30.2, C31.2, R8.1, R9.1, R13.1, U4.1 (GND), U5.7 (GND), U5.9 (GND); also elsewhere on the board
unnamed: C15.1, R7.1
unnamed: C27.2, R10.2, R11.2
unnamed: C23.1, U4.6 (BOOT)
unnamed: C27.1, R9.2, R10.1, U4.4 (FB)
unnamed: C23.2, L1.1, U4.2 (SW)
unnamed: C24.2, U5.1 (BOOT)
unnamed: R7.2, U5.6 (COMP)
unnamed: R12.1, R13.2, U5.5 (FB)
unnamed: R8.2, U5.4 (RT/CLK)
unnamed: C24.1, L2.1, U5.8 (SW)
V_{power}: C12.1, C16.1, C25.1, C28.1, C29.1, C30.1, C31.1, U4.3 (VIN), U5.2 (VIN), U5.3 (EN); also elsewhere on the board

Notes on the sheet:
VIN-5V0-device
VIN-5V0-assist

Parts:
C1, C3, C7: 1uF; C_0402_1005Metric
C2, C4, C5, C6: 0.1uF; C_0402_1005Metric
C8, C9: 22pF; C_0402_1005Metric
C10: NC; C_0402_1005Metric; not fitted
D1: PESD1CAN; SOT-23-3; LCSC Part C2687121
J1: Conn_01x06_GH1.25; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
R1: 1K; R_0402_1005Metric; not fitted
R2: 10K; R_0402_1005Metric
R3, R4: 60R; R_0402_1005Metric
R5, R6: 0R; R_0402_1005Metric
SW1: RST; SW-SMD_L3.9-W3.0-P4.45; LCSC Part C455280
TP1: TestPoint_Probe; TestPoint_Pad_D1.0mm
U1: XC6206PxxxMR; SOT-23-3
U2: AT32F425K8U7-4; QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm; LCSC Part C5454459
U3: TJA1044GTK/3Z; HVSON-8-1EP_3x3mm_P0.65mm_EP1.6x2.4mm; LCSC Part C2157795
Y1: 16MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
5V0_{assist}: C1.1, U1.3 (VI), U3.3 (VCC); also elsewhere on the board
/mcu/3V3: C2.1, C3.1, C4.1, C5.1, C7.1, J1.2, R1.1, TP1.1, U1.2 (VO), U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U3.5 (VIO)
/mcu/BOOT0: R1.2, R2.2, U2.31 (BOOT0)
/mcu/CANH_IN: D1.2, R6.2, U3.7 (CANH)
/mcu/CANL_IN: D1.1, R5.2, U3.6 (CANL)
/mcu/CAN_RX: U2.21 (PA11), U3.4 (RXD)
/mcu/CAN_TX: U2.22 (PA12), U3.1 (TXD)
/mcu/NRST: C6.1, SW1.2, U2.4 (NRST)
/mcu/OSC_IN: C8.2, U2.2 (PF0), Y1.3
/mcu/OSC_OUT: C9.2, U2.3 (PF1), Y1.1
/mcu/SWCLK: J1.6, U2.24 (PA14)
/mcu/SWDIO: J1.5, U2.23 (PA13)
/mcu/UART1_RX: J1.4, U2.20 (PA10)
/mcu/UART1_TX: J1.3, U2.19 (PA9)
CANH: R4.2, R6.1; also elsewhere on the board
CANL: R3.1, R5.1; also elsewhere on the board
CTRL_RX: U2.12 (PA6); also elsewhere on the board
CTRL_TX: U2.13 (PA7); also elsewhere on the board
EXT_LED_1: U2.6 (PA0); also elsewhere on the board
EXT_LED_2: U2.7 (PA1); also elsewhere on the board
EXT_LED_3: U2.8 (PA2); also elsewhere on the board
EXT_LED_4: U2.9 (PA3); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, D1.3, J1.1, J1.MP (MountPin), R2.1, SW1.1, U1.1 (GND), U2.33 (VSS/VSSA), U3.2 (GND), U3.8 (STB), U3.9 (EP), Y1.2, Y1.4; also elsewhere on the board
unnamed: C10.1, R3.2, R4.1

Notes on the sheet:
Debug Interface
BOOT0
MCU

Parts:
C32, C34, C35, C37, C38, C40, C41, C42, C44, C45, C47, C50: 1uF; C_0402_1005Metric
C33, C43, C48, C49, C51: 0.1uF; C_0402_1005Metric
C36: 10uF/6.3V; C_0603_1608Metric
C39: 1nF; C_0402_1005Metric
C46: 10uF/10V; C_0402_1005Metric
D2: LED_NET_Y; LED_0402_1005Metric
D3: LED_NET_G; LED_0402_1005Metric
D4, D5: ESD5Vxx; D_SOD-523
L3: HY601680; XFMR-SMD_HY601680; LCSC Part C14078
R14: 0R; R_0402_1005Metric
R15: 0R; R_0402_1005Metric; not fitted
R16, R19: 75R; R_0402_1005Metric
R17, R18: 1K; R_0402_1005Metric
R20, R21: 56K; R_0402_1005Metric
TP2, TP3: TestPoint_Probe; TestPoint_Pad_D1.0mm
U6, U8: XC6206PxxxMR; SOT-23-3
U7: CH397A; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm; LCSC Part C7465328
U9, U11: CH343P; TQFN-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm; LCSC Part C2846043
U10: CH334P; QFN-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm; LCSC Part C5373042
USB1: TYPE-C 16PIN 2MD(073); USB-C-SMD_TYPE-C-6PIN-2MD-073; LCSC Part C2765186
Y2: 25MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm
Y3: 12MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
5V0_{assist}: C35.1, C41.1, C44.1, C50.1, R15.2, U6.3 (VI), U8.3 (VI), U9.3 (VDD5), U9.9 (VBUS), U10.15 (V5), U11.3 (VDD5), U11.9 (VBUS); also elsewhere on the board
/usb/3V3: C42.1, C45.1, C46.1, C47.1, C49.1, C51.1, TP3.1, U8.2 (VO), U9.1 (VIO), U10.16 (VDD33), U11.1 (VIO)
/usb/3V3_CH397A: C33.1, C36.1, C38.1, D2.2 (A), D3.2 (A), R14.2, TP2.1, U6.2 (VO), U7.1 (AVDD33), U7.10 (AVDD33), U7.13 (VDDIO), U7.18 (VDDIO)
/usb/AVDDK: C37.1, U7.23 (AVDDK)
/usb/CC1: R20.2, USB1.4 (CC1)
/usb/CC2: R21.2, USB1.10 (CC2)
/usb/DVDDK: C40.1, U7.9 (DVDDK)
/usb/HUB_OSC_IN: U10.2 (XI), Y3.3
/usb/HUB_OSC_OUT: U10.1 (XO), Y3.1
/usb/LED0: R17.2, U7.15 (LED0)
/usb/LED1: R18.2, U7.17 (LED1)
/usb/MDI_RXN: L3.1, U7.5 (MDIRN)
/usb/MDI_RXP: L3.3, U7.4 (MDIRP)
/usb/MDI_TXN: L3.6, U7.3 (MDITN)
/usb/MDI_TXP: L3.8, U7.2 (MDITP)
/usb/OSC_IN: U7.21 (XI), Y2.3
/usb/OSC_OUT: U7.22 (XO), Y2.1
/usb/USB_1_DN: U9.8 (UD-), U10.3 (DM4)
/usb/USB_1_DP: U9.7 (UD+), U10.4 (DP4)
/usb/USB_2_DN: U7.7 (UDM), U10.5 (DM3)
/usb/USB_2_DP: U7.8 (UDP), U10.6 (DP3)
/usb/USB_3_DN: U10.7 (DM2), U11.8 (UD-)
/usb/USB_3_DP: U10.8 (DP2), U11.7 (UD+)
/usb/USB_HUB_DN: D4.1 (K), U10.11 (DMU), USB1.5 (DN2), USB1.7 (DN1)
/usb/USB_HUB_DP: D5.1 (K), U10.12 (DPU), USB1.6 (DP1), USB1.8 (DP2)
/usb/V5_CH397A: R14.1, R15.1, U7.11 (V5)
/usb/VBUS: R20.1, R21.1, USB1.2 (VBUS), USB1.11 (VBUS)
CTRL_RX: U9.4 (TXD); also elsewhere on the board
CTRL_TX: U9.5 (RXD); also elsewhere on the board
GND: C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, D4.2 (A), D5.2 (A), U6.1 (GND), U7.6 (GND), U7.24 (GND), U7.25 (GND), U8.1 (GND), U9.2 (GND), U9.17 (EP), U10.17 (GND), U11.2 (GND), U11.17 (EP), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHELL), USB1.14 (SHELL), Y2.2, Y2.4, Y3.2, Y3.4; also elsewhere on the board
Lora_RX: U11.4 (TXD); also elsewhere on the board
Lora_TX: U11.5 (RXD); also elsewhere on the board
MID360_RXN: L3.16; also elsewhere on the board
MID360_RXP: L3.14; also elsewhere on the board
MID360_TXN: L3.11; also elsewhere on the board
MID360_TXP: L3.9; also elsewhere on the board
unnamed: C32.1, L3.2
unnamed: C34.1, L3.7
unnamed: C39.1, R16.2, R19.2
unnamed: D2.1 (K), R17.1
unnamed: D3.1 (K), R18.1
unnamed: L3.10, R16.1
unnamed: L3.15, R19.1
unnamed: C43.1, U9.6 (V3)
unnamed: C48.1, U11.6 (V3)
USB_4_DN: U10.9 (DM1); also elsewhere on the board
USB_4_DP: U10.10 (DP1); also elsewhere on the board

Notes on the sheet:
USB转串口（MCU）
type-c 接口
USB转串口（LORA）
USB-HUB
内外LDO选择(删去外部LDO并更换跳线电阻则改为内部降压，温度高)

Parts:
D10: SMAJ28CA; D_SMA
F1, F2, F3, F4: 24V@0.75A; Fuse_1812_4532Metric
F5: 24V@1.5A; Fuse_1812_4532Metric
J2, J3, J4, J5: Conn_01x02_XH2.54; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J6, J8, J9: KF2EDGR-3.81-2P; CONN-TH_2P-P3.81_KF2EDGR-3.81-2P; LCSC Part C441182
J7, J10, J11, J12: Conn_01x04_GH1.25; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J13: Conn_01x08_GH1.25; JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal
Q1, Q2, Q3, Q4: SI2306A; SOT-23; LCSC Part C347489
R26, R27, R30, R31: 10K; R_0402_1005Metric
R28, R29, R32, R33: 100R; R_0402_1005Metric

Connections:
5V0_{device}: J7.1, J10.1; also elsewhere on the board
CANH: J11.2, J12.2; also elsewhere on the board
CANL: J11.1, J12.1; also elsewhere on the board
EXT_LED_1: R33.2; also elsewhere on the board
EXT_LED_2: R32.2; also elsewhere on the board
EXT_LED_3: R28.2; also elsewhere on the board
EXT_LED_4: R29.2; also elsewhere on the board
GND: D10.1 (A1), J6.2, J7.4, J7.MP (MountPin), J8.2, J9.2, J10.4, J10.MP (MountPin), J11.4, J11.MP (MountPin), J12.4, J12.MP (MountPin), J13.1, J13.2, J13.MP (MountPin), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R26.2, R27.2, R30.2, R31.2; also elsewhere on the board
Lora_RX: J7.3; also elsewhere on the board
Lora_TX: J7.2; also elsewhere on the board
MID360_RXN: J13.5; also elsewhere on the board
MID360_RXP: J13.6; also elsewhere on the board
MID360_TXN: J13.7; also elsewhere on the board
MID360_TXP: J13.8; also elsewhere on the board
unnamed: J2.1, Q1.3 (D)
unnamed: F1.1, J2.2
unnamed: J3.1, Q2.3 (D)
unnamed: F2.1, J3.2
unnamed: J4.1, Q3.3 (D)
unnamed: F3.1, J4.2
unnamed: J5.1, Q4.3 (D)
unnamed: F4.1, J5.2
unnamed: F5.1, J13.3, J13.4
unnamed: Q1.1 (G), R26.1, R28.1
unnamed: Q2.1 (G), R27.1, R29.1
unnamed: Q3.1 (G), R30.1, R32.1
unnamed: Q4.1 (G), R31.1, R33.1
USB_4_DN: J10.3; also elsewhere on the board
USB_4_DP: J10.2; also elsewhere on the board
V_{power}: D10.2 (A2), F1.2, F2.2, F3.2, F4.2, F5.2, J6.1, J8.1, J9.1; also elsewhere on the board

Notes on the sheet:
扩展串口-Lora模块
电源输入
扩展USB - WIFI模块
扩展LED输出
分电输出
CAN 接口

Parts:
C52, C53, C55: 100uF/35V; CP_Elec_6.3x7.7
C54: 10uF/35V; CP_Elec_4x5.4
C56, C58, C60, C61: 0.1uF; C_0402_1005Metric
C57: 22uF/35V; CP_Elec_5x5.4
C59: 1uF; C_0402_1005Metric
C62, C63: 330pF; C_0402_1005Metric
D6: LED_CHG_B; LED_0402_1005Metric
D7: LED_PWR_R; LED_0402_1005Metric
D8, D9: ESD5Vxx; D_SOD-523
L4: 22uH; L_APV_APH1040
R22: 33K/1%; R_0402_1005Metric
R23: 10mR; R_0805_2012Metric
R24, R25: 2K; R_0402_1005Metric
U12: SW3526; QFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
USB2: TYPE-C 16PIN 2MD(073); USB-C-SMD_TYPE-C-6PIN-2MD-073; LCSC Part C2765186

Connections:
/power/VIN-5V0-SBC/CC1: C62.1, U12.18 (CC1), USB2.4 (CC1)
/power/VIN-5V0-SBC/CC2: C63.1, U12.19 (CC2), USB2.10 (CC2)
/power/VIN-5V0-SBC/CSN: C61.2, R23.2, U12.24 (CSN), USB2.2 (VBUS), USB2.11 (VBUS)
/power/VIN-5V0-SBC/CSP: C53.1, C55.1, C57.1, C60.1, C61.1, L4.2, R23.1, U12.1 (CSP)
/power/VIN-5V0-SBC/FLED: R24.2, U12.22 (FLED)
/power/VIN-5V0-SBC/USB_DN: D8.1 (K), U12.21 (DM), USB2.5 (DN2), USB2.7 (DN1)
/power/VIN-5V0-SBC/USB_DP: D9.1 (K), U12.20 (DP), USB2.6 (DP1), USB2.8 (DP2)
/power/VIN-5V0-SBC/VDRV: C59.1, D6.2 (A), D7.2 (A), U12.10 (VDRV)
GND: C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C59.2, C60.2, C62.2, C63.2, D8.2 (A), D9.2 (A), R22.2, R25.2, U12.25 (GND(EPAD)), USB2.1 (GND), USB2.12 (GND), USB2.13 (SHELL), USB2.14 (SHELL); also elsewhere on the board
unnamed: C58.2, L4.1, U12.2 (SW), U12.3 (SW), U12.4 (SW), U12.5 (SW), U12.6 (SW)
unnamed: D6.1 (K), R24.1
unnamed: D7.1 (K), R25.1
unnamed: C58.1, U12.7 (BST)
unnamed: R22.1, U12.12 (PSET)
V_{power}: C52.1, C54.1, C56.1, U12.13 (VIN), U12.14 (VIN), U12.15 (VIN), U12.16 (VIN); also elsewhere on the board

Notes on the sheet:
输出功率设置
0K 18W; 3.9K 24W; 9.1K 30W; 16K 45W; 24K 60W; 33K 65W;

Board: 2 copper layers, 99.6 x 88.1 mm, 173 parts (10 on the bottom side), 105 nets.

## Commit log

2025-07-25 暂存: 基本完成原理图(未分配封装，未ERC)
2025-07-25 暂存: 基本完成原理图(差雷达接口)
2025-07-26 暂存: 布局布线基本完成(DRC未过，GND不全)
2025-07-27 提交生产: 2507271646
2025-08-13 fix: 修正TPS54302反馈电阻值
2025-08-25 pref: USB外设改自供电，优化布线
